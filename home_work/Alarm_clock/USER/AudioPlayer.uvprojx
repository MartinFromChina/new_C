# Keil uVision project AudioPlayer.uvprojx, settings and files
target AudioPlayer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: AudioPlayer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER  ARM_COMPILER_PRESENT  X_TASK_LOG_DEBUG_METHOD=SeggerRTT_LogDebug
  c misc: --diag_suppress=870
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\FWLIB\inc;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\I2S;..\HARDWARE\WM8978;..\APP;..\AUDIOCODEC\wav;..\new_user;..\new_user\task;..\new_user\MVC;..\..\..\module\common;..\..\..\module\common\InsertLog;..\..\..\module\common\loopqueue;..\..\..\module\common\StateMachine;..\..\..\module\common\priorityqueue;..\..\..\module\common\Math;..\..\..\module\component\const_loop_scheduler;..\..\..\module\component\const_loop_scheduler\TemplateTask;..\..\..\module\component\const_loop_scheduler\HierarchicalSM;..\..\..\module\component\BlockableStateMachine;..\..\..\module\customize\ButtonModule;..\..\..\module\external\Segger\SEGGER_RTT_V640\Syscalls;..\..\..\module\external\Segger\SEGGER_RTT_V640\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/WM8978/: wm8978.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group AUDIOCODEC
    ../AUDIOCODEC/wav/: wavplay.c
  group APP
    ../APP/: audioplay.c
  group README
    ../: readme.txt
  group task
    ../new_user/task/: mTask.c mApp_MainTask.c ButtonTask.c TestModeTask.c ConfigParamPoll_task.c
  group MVC
    ../new_user/MVC/: all_class_init.c controller.c model.c view.c
  group Extern
    ../../../module/common/: AppCommon.c
    ../../../module/common/loopqueue/: loop_queues.c
    ../../../module/common/Math/: bit_operation.c
    ../../../module/common/StateMachine/: StateMachine.c
    ../../../module/common/InsertLog/: InsertLogDebug.c
    ../../../module/component/const_loop_scheduler/: const_loop_scheduler.c x_task_common.c
    ../../../module/component/const_loop_scheduler/TemplateTask/: template_task.c
    ../../../module/component/const_loop_scheduler/HierarchicalSM/: h_state_machine.c
    ../../../module/component/BlockableStateMachine/: b_StateMachine.c
    ../../../module/customize/ButtonModule/: ButtonModule.c
    ../../../module/customize/TestModeConsole/: mTestMode.c
  group Segger
    ../../../module/external/Segger/SEGGER_RTT_V640/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
    ../../../module/external/Segger/SEGGER_RTT_V640/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group LogDebug
    ../new_user/: LogDebugSwitch.c
