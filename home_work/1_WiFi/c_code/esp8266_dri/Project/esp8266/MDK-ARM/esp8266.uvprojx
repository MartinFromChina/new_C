# Keil uVision project esp8266.uvprojx, settings and files
target esp8266 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: esp8266 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\..\..\..\..\module\external\Segger\SEGGER_RTT_V640\RTT;..\..\..\User\LogDebug;..\..\..\User\App;..\..\..\User\Module;..\..\..\User\Func;..\..\..\User\Drive;..\..\..\..\..\..\..\module\common\InsertLog;..\..\..\..\..\..\..\module\common\StateMachine;..\..\..\..\..\..\..\module\common\loopqueue;..\..\..\..\..\..\..\module\customize\ButtonModule;..\..\..\..\..\..\..\module\common\Math
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Segger
    ../../../../../../../module/external/Segger/SEGGER_RTT_V640/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../../module/external/Segger/SEGGER_RTT_V640/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
  group External
    ../../../../../../../module/common/InsertLog/: InsertLogDebug.c
    ../../../../../../../module/common/loopqueue/: loop_queues.c
    ../../../../../../../module/common/StateMachine/: StateMachine.c
    ../../../../../../../module/common/: AppCommon.c
    ../../../../../../../module/customize/LedDirectDisplay/: LedDirectDisplay.c
    ../../../../../../../module/customize/TestModeConsole/: mTestMode.c
    ../../../../../../../module/customize/ButtonModule/: ButtonModule.c
    ../../../../../../../module/common/Math/: bit_operation.c
  group App
    ../../../User/App/: App_Main.c ProjectConfig.h mApp_Init.c
  group Module
    ../../../User/Module/: mModule.c mModule_button.c
  group Func
    ../../../User/Func/: mFunc.c mFunc_SoftTimer.c mFunc_Button.c
  group Drive
    ../../../User/Drive/: MCU_Board_Speci.h mDrive.c mDri_SoftTimer.c mDri_GPIO.c
  group LogDebug
    ../../../User/LogDebug/: LogDebugSwitch.c LogDebugSwitch.h
software components: CMSIS:CORE 4.3.0
